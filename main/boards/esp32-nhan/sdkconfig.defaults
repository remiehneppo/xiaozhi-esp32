## main/boards/esp32-nhan/sdkconfig.defaults
```kconfig
CONFIG_BOARD_TYPE_ESP32_NHAN=y
CONFIG_SPIRAM=n
CONFIG_WAKE_WORD_DISABLED=y
CONFIG_USE_AFE_WAKE_WORD=n
CONFIG_USE_AUDIO_PROCESSOR=n
```
